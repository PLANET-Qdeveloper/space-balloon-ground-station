# Repository PLANET-Qdeveloper/space-balloon-ground-station

## KiCad design hardware/LoRa+GNSS_Transceiver_Board_REV2/GroundStation_3.kicad_pcb

Parts:
C1: 3.3u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C17, C19, C21, C26, C27, C29, C30, C31, C32, C37, C38, C39, C41, C42, C43, C44, C45: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4: 27p（C0G/NP0）; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16, C33: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18, C20: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C22, C23, C24, C25, C40: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C28: 1206AC472KAZ1A; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C34, C35, C36: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
D1, D3: MA10EB045; D_SOD-123
D2, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: LED_Small; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F2: 1210L300SLWR; Fuse_1210_3225Metric_Pad1.42x2.65mm_HandSolder
FB1: FerriteBead_Small; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB2, FB3: FerriteBead; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB4: MI0805K601R-10; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
IC1: XC8114AA01PR-G; XC6901D901PRG; Manufacturer_Part_Number XC8114AA01PR-G
IC2: TBD62384AFWG; SOIC-18W_7.5x11.6mm_P1.27mm; Manufacturer_Part_Number TBD62384AFWG; Mouser Part Number N/A
J2: USB_B; USB_B_OST_USB-B1HSxx_Horizontal
Q7: TBD62083AFWG; SOIC-18W_7.5x11.6mm_P1.27mm; Manufacturer_Part_Number TBD62083AFWG; Mouser Part Number 757-TBD62083AFWG
R2, R9, R10, R11, R12: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R8, R14, R15, R16: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 12k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R17, R18, R19, R20, R21, R22: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R13, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23, R24, R25, R26: 500; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R39: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R40: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R51: PTN1206E1004BST1; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
S1, S2, S3, S4, S5, S6, S7: SS12SDP2; Mouser Part Number 633-SS12SDP2
SW1, SW2: PTS645SK50SMTR92LFS; SW4_PTS645SK50SMTR92LFS_CNK
TP1: TestPoint; TestPoint_Pad_D1.5mm
U1: ADP151AUJZ-3.3; TSOT-23-5
U2: FT4233HPQ-REEL; QFN-76-1EP_9x9mm_P0.4mm_EP5.81x6.31mm; PARTREV 1.1
U3: 93LCxxB; SOIC-8_3.9x4.9mm_P1.27mm
U4: SN74HCT245PWR; TSSOP-20_4.4x6.5mm_P0.65mm
U5, U6, U7: E22-900T30D_E220-900T22S(JP)_versatile
U8: SAM-M10Q-00B; SAM-M10Q(Hand_Solder)
U9: USBLC6-2SC6; SOT-23-6
U10, U13: DG4053EEQ-T1-GE3; TSSOP-16_4.4x5mm_P0.65mm
U11: ADP3338AKCZ-3.3; SOT-223_DIO
Y1: FA-238V_12.0000MA-C5; Crystal_SMD_SeikoEpson_FA238V-4Pin_3.2x2.5mm; PARTREV N/A

Connections:
+3V3: C10.1, C11.1, C12.1, C13.1, C15.1, C19.1, C20.1, C22.1, C44.1, C45.1, D3.2 (A), D4.2 (A), FB1.1, FB2.1, FB3.1, R3.2, R4.2, R8.1, R15.2, S1.1 (NC), S2.1 (NC), S3.1 (NC), S4.1 (NC), S5.1 (NC), S6.1 (NC), S7.1 (NC), U2.12 (VCCIO), U2.28 (VCCIO), U2.41 (VCCIO), U2.54 (VCCIO), U2.69 (PD1_VCONN), U3.8 (VCC), U10.16 (V+), U11.2 (OUT), U11.4 (OUT), U13.16 (V+)
+3V3_GNSS: C23.1, C29.1, C30.1, C31.1, C33.1, D1.2 (A), D5.2 (A), R14.1, U1.5 (VOUT), U8.2 (V_IO), U8.3 (V_BCKP), U8.17 (VCC)
/GNSS_TIMEPULSE: D6.2 (A), U8.7 (TIMEPULSE)
/LORA_A_M0: Q7.1 (I1), U2.16 (ADBUS5), U5.1 (M0), U13.14 (X)
/LORA_A_M1: Q7.2 (I2), U2.17 (ADBUS6), U5.2 (M1), U10.14 (X)
/LORA_B_M0: Q7.3 (I3), U2.24 (BDBUS5), U6.1 (M0), U13.15 (Y)
/LORA_B_M1: Q7.4 (I4), U2.25 (BDBUS6), U6.2 (M1), U10.15 (Y)
/LORA_C_M0: Q7.5 (I5), U2.42 (CDBUS5), U7.1 (M0), U13.4 (Z)
/LORA_C_M1: Q7.6 (I6), U2.43 (CDBUS6), U7.2 (M1), U10.4 (Z)
/UART_A_MISO: U2.9 (ADBUS1), U4.2 (A1), U5.4 (TXD)
/UART_A_MOSI: U2.8 (ADBUS0), U4.3 (A2), U5.3 (RXD)
/UART_A_~CTS: U2.14 (ADBUS3), U5.5 (AUX)
/UART_A_~DTR: U2.15 (ADBUS4), U13.12 (X0)
/UART_A_~RTS: U2.13 (ADBUS2), U10.12 (X0)
/UART_B_MISO: U2.20 (BDBUS1), U4.4 (A3), U6.4 (TXD)
/UART_B_MOSI: U2.19 (BDBUS0), U4.5 (A4), U6.3 (RXD)
/UART_B_~CTS: U2.22 (BDBUS3), U6.5 (AUX)
/UART_B_~DTR: U2.23 (BDBUS4), U13.2 (Y0)
/UART_B_~RTS: U2.21 (BDBUS2), U10.2 (Y0)
/UART_C_MISO: U2.37 (CDBUS1), U4.6 (A5), U7.4 (TXD)
/UART_C_MOSI: U2.36 (CDBUS0), U4.7 (A6), U7.3 (RXD)
/UART_C_~CTS: U2.39 (CDBUS3), U7.5 (AUX)
/UART_C_~DTR: U2.40 (CDBUS4), U13.5 (Z0)
/UART_C_~RTS: U2.38 (CDBUS2), U10.5 (Z0)
/UART_D_MISO: U2.49 (DDBUS1), U8.13 (TXD)
/UART_D_MOSI: U2.48 (DDBUS0), U8.14 (RXD)
/UART_D_~CTS: U2.51 (DDBUS3)
/UART_D_~DCD: U2.56 (DDBUS6)
/UART_D_~DSR: R16.1, U2.53 (DDBUS5), U10.9 (C), U10.10 (B), U10.11 (A), U13.9 (C), U13.10 (B), U13.11 (A)
/UART_D_~DTR: U2.52 (DDBUS4)
/UART_D_~RTS: U2.50 (DDBUS2)
/USB_DM: U2.63 (DM), U9.4 (I/O2)
/USB_DP: U2.64 (DP), U9.6 (I/O1)
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), IC1.1 (VSS), IC1.2 (EP_1), IC1.6 (EP_2), IC1.7 (EP_3), IC2.9 (GND), J2.4 (GND), Q7.9 (GND), R2.1, R5.1, R9.1, R10.1, R11.1, R12.1, R23.1, R24.1, R25.1, R26.1, R39.2, R51.2, S1.3 (NO), S2.3 (NO), S3.3 (NO), S4.3 (NO), S5.3 (NO), S6.3 (NO), S7.3 (NO), SW1.1, SW1.2, SW2.1, SW2.2, U1.2 (GND), U2.3 (TEST), U2.11 (GND), U2.31 (GND), U2.55 (GND), U2.77 (EXP), U3.5 (GND), U4.8 (A7), U4.9 (A8), U4.10 (GND), U4.19 (~OE), U5.7 (GND), U5.8 (GND), U5.9 (GND), U5.10 (GND), U5.11 (GND), U6.7 (GND), U6.8 (GND), U6.9 (GND), U6.10 (GND), U6.11 (GND), U7.7 (GND), U7.8 (GND), U7.9 (GND), U7.10 (GND), U7.11 (GND), U8.1 (GND), U8.4 (GND), U8.5 (GND), U8.6 (GND), U8.10 (GND), U8.11 (GND), U8.15 (GND), U8.16 (GND), U8.20 (GND), U9.2 (GND), U10.6 (ENABLE), U10.7 (V-), U10.8 (GND), U11.1 (GND), U13.6 (ENABLE), U13.7 (V-), U13.8 (GND), Y1.2 (GND), Y1.4 (GND)
unnamed: D2.1 (K), R26.2
unnamed: D4.1 (K), R23.2
unnamed: D5.1 (K), R24.2
unnamed: D6.1 (K), R25.2
unnamed: D7.1 (K), R27.2
unnamed: D8.1 (K), R28.2
unnamed: D9.1 (K), R29.2
unnamed: D10.1 (K), R30.2
unnamed: D11.1 (K), R31.2
unnamed: D12.1 (K), R32.2
unnamed: D13.1 (K), R33.2
unnamed: D14.1 (K), R34.2
unnamed: D15.1 (K), R35.2
unnamed: D16.1 (K), R36.2
unnamed: D17.1 (K), R37.2
unnamed: D18.1 (K), R38.2
unnamed: C26.1, C40.1, FB4.2, IC1.3 (EN), IC1.4 (VIN)
unnamed: IC2.1 (I1), U4.18 (B1)
unnamed: IC2.2 (I2), U4.17 (B2)
unnamed: IC2.3 (I3), U4.16 (B3)
unnamed: IC2.4 (I4), U4.15 (B4)
unnamed: IC2.5 (I5), U4.14 (B5)
unnamed: IC2.6 (I6), U4.13 (B6)
unnamed: IC2.18 (O1), R33.1
unnamed: IC2.17 (O2), R34.1
unnamed: IC2.16 (O3), R35.1
unnamed: IC2.15 (O4), R36.1
unnamed: IC2.14 (O5), R37.1
unnamed: IC2.13 (O6), R38.1
unnamed: J2.3 (D+), U9.1 (I/O1)
unnamed: J2.2 (D-), U9.3 (I/O2)
unnamed: C28.1, J2.5 (Shield), R51.1
unnamed: F2.1, J2.1 (VBUS)
unnamed: Q7.18 (O1), R27.1
unnamed: Q7.17 (O2), R28.1
unnamed: Q7.16 (O3), R29.1
unnamed: Q7.15 (O4), R30.1
unnamed: Q7.14 (O5), R31.1
unnamed: Q7.13 (O6), R32.1
unnamed: R7.2, SW2.3, SW2.4
unnamed: R13.2, SW1.3, SW1.4
unnamed: R16.2, S1.2 (COM)
unnamed: R17.1, S2.2 (COM)
unnamed: R18.1, S3.2 (COM)
unnamed: R19.1, S4.2 (COM)
unnamed: R20.1, S5.2 (COM)
unnamed: R21.1, S6.2 (COM)
unnamed: R22.1, S7.2 (COM)
unnamed: R15.1, U2.1 (EECLK), U3.2 (SCLK)
unnamed: R3.1, U2.76 (EECS), U3.1 (CS)
unnamed: R6.2, U2.2 (EEDATA), U3.3 (DI)
unnamed: C3.2, U2.29 (OSCI), Y1.1
unnamed: C4.2, U2.30 (OSCO), Y1.3
unnamed: R2.2, U2.70 (PD1_CC1)
unnamed: R9.2, U2.67 (PD1_CC2)
unnamed: R39.1, R40.2, U2.68 (PD1_SVBUS)
unnamed: R11.2, U2.71 (PD2_CC1)
unnamed: R12.2, U2.73 (PD2_CC2)
unnamed: R10.2, U2.72 (PD2_SVBUS)
unnamed: R5.2, U2.65 (REF)
unnamed: C6.1, FB2.2, U2.66 (VCC_PD)
unnamed: C14.1, C18.1, FB3.2, U2.62 (VCC_USB)
unnamed: C16.1, C17.1, FB1.2, U2.32 (VREGIN)
unnamed: C21.1, R7.1, R8.2, U2.4 (~RESET)
unnamed: R4.1, R6.1, U3.4 (DO)
unnamed: C32.1, R13.1, R14.2, U8.18 (RESET_N)
unnamed: F2.2, FB4.1, TP1.1 (1_1), U9.5 (VBUS)
unnamed: R20.2, U10.13 (X1)
unnamed: R21.2, U10.1 (Y1)
unnamed: R22.2, U10.3 (Z1)
unnamed: R17.2, U13.13 (X1)
unnamed: R18.2, U13.1 (Y1)
unnamed: R19.2, U13.3 (Z1)
VBUS: C24.1, C25.1, C27.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C41.1, C42.1, C43.1, D1.1 (K), D2.2 (A), D3.1 (K), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), IC1.5 (VOUT), IC2.10 (VCC), Q7.10 (COMMON), R40.1, U1.1 (VIN), U1.3 (EN), U4.1 (DIR), U4.20 (VCC), U5.6 (VCC), U6.6 (VCC), U7.6 (VCC), U11.3 (IN)
VCORE: C1.1, C2.1, C5.1, C7.1, C8.1, C9.1, U2.10 (VCORE), U2.27 (VCORE), U2.33 (VREGOUT), U2.47 (VCORE), U2.74 (VCORE)

Notes on the sheet:
USB to Serial IC
切り替えスイッチ
LED
- RTS，CTS，DTRはアクティブLOW．
Mounting Hole (M3)
8ch Dチャネルトランジスタアレイ（ハイアクティブタイプ）
GNSS
電源回路
Fuse(6V1A)
8ch Bus トランシーバー(レベルシフタ) + 8ch Dチャネルトランジスタアレイ（ローアクティブタイプ）
LoRa
- Analog Triple SPDT switch LoRaのM0，M1ピンのHIGH/LOW切り替えをPC側から行うかスライドスイッチで 行うか(Auto/Manual)を選択するためのアナログスイッチ．M0ピンは各チャンネルのDTR， M1ピンはRTSに接続されている．また，Auto/Manual検知はDチャンネルのDSR， M0，M1の状態検知はA~CチャンネルのDSRとDCDに接続されている．

Board: 4 copper layers, 100.0 x 70.0 mm, 139 parts (50 on the bottom side), 105 nets.
